# Keil uVision project wb09test.uvprojx, settings and files
target wb09test (6220000::V6.22::ARMCLANG)
  device: STM32WB09KEVx STMicroelectronics
  pack: Keil.STM32WB0x_DFP.1.0.0
  cpu: IRAM(0x20000018,0x00003FE8) IRAM2(0x20004000,0x00004000) IROM(0x10040000,0x00080000) XRAM(0x20008000,0x00004000) XRAM2(0x2000C000,0x00004000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: wb09test +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_FULL_LL_DRIVER,USE_HAL_DRIVER,STM32WB09
  c misc: -fshort-enums
  c include: ../Core/Inc;../STM32_BLE/App;../STM32_BLE/Target;../System/Config/Debug_GPIO;../System/Interfaces;../System/Modules;../System/Modules/Flash;../System/Modules/NVMDB/Inc;../System/Modules/PKAMGR/Inc;../System/Modules/Profiles/Inc;../System/Modules/RADIO_utils/Inc;../System/Modules/RTDebug;../System/Startup;../Utilities/trace/adv_trace;../Drivers/STM32WB0x_HAL_Driver/Inc;../Drivers/STM32WB0x_HAL_Driver/Inc/Legacy;../Utilities/misc;../Utilities/sequencer;../Utilities/lpm/tiny_lpm;../Middlewares/ST/STM32_BLE;../Middlewares/ST/STM32_BLE/cryptolib/Inc;../Middlewares/ST/STM32_BLE/cryptolib/Inc/Common;../Middlewares/ST/STM32_BLE/cryptolib/Inc/AES;../Middlewares/ST/STM32_BLE/cryptolib/Inc/AES/CBC;../Middlewares/ST/STM32_BLE/cryptolib/Inc/AES/CMAC;../Middlewares/ST/STM32_BLE/cryptolib/Inc/AES/Common;../Middlewares/ST/STM32_BLE/cryptolib/Inc/AES/ECB;../Drivers/CMSIS/Device/ST/STM32WB0X/Include;../Middlewares/ST/STM32_BLE/evt_handler/inc;../Middlewares/ST/STM32_BLE/queued_writes/inc;../Middlewares/ST/STM32_BLE/stack/include;../Drivers/CMSIS/Include
  asm misc: -x assembler-with-cpp
  memory RVCT4: ROM 0x10040000 size 0x80000
  memory RVCT6: ROM 0x20008000 size 0x4000
  memory RVCT7: ROM 0x2000c000 size 0x4000
  memory RVCT9: RAM 0x20000018 size 0x3fe8
  memory RVCT10: RAM 0x20004000 size 0x4000
  scatter file: stm32wb09_flash.sct
  link misc: --diag_suppress L6312W
--diag_suppress L6314W
--diag_suppress L6329W
  group Application/MDK-ARM
    ./: startup_stm32wb09.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c memorymap.c pka.c radio.c radio_timer.c rtc.c app_entry.c usart.c stm32wb0x_it.c stm32wb0x_hal_msp.c
  group Application/User/System/Startup
    ../System/Startup/: cpu_context_switch.s device_context_switch.c
  group Application/User/System/Interfaces
    ../System/Interfaces/: stm32_lpm_if.c cryptolib_hw_aes.c hw_aes.c hw_pka.c hw_rng.c usart_if.c
  group Application/User/System/Modules
    ../System/Modules/: blue_unit_conversion.s osal_memcpy.s miscutil.c osal.c stm_list.c
  group Application/User/System/Modules/PKAMGR
    ../System/Modules/PKAMGR/Src/: pka_manager.c
  group Application/User/System/Modules/RADIO_utils
    ../System/Modules/RADIO_utils/Src/: RADIO_utils.c
  group Application/User/System/Modules/RTDebug
    ../System/Modules/RTDebug/: RTDebug.c
  group Application/User/System/Modules/Profiles
    ../System/Modules/Profiles/Src/: gap_profile.c gatt_profile.c
  group Application/User/System/Modules/Flash
    ../System/Modules/Flash/: flash_driver.c flash_manager.c
  group Application/User/System/Modules/NVMDB
    ../System/Modules/NVMDB/Src/: nvm_db.c nvm_db_conf.c
  group Application/User/System/Config/Debug_GPIO
    ../System/Config/Debug_GPIO/: app_debug.c
  group Application/User/STM32_BLE/Target
    ../STM32_BLE/Target/: blenvm.c bleplat.c bleplat_cntr.c
  group Application/User/STM32_BLE/App
    ../STM32_BLE/App/: app_ble.c my_svc.c my_svc_app.c
  group Drivers/STM32WB0x_HAL_Driver
    ../Drivers/STM32WB0x_HAL_Driver/Src/: stm32wb0x_hal_rcc.c stm32wb0x_hal_rcc_ex.c stm32wb0x_hal_flash.c stm32wb0x_hal_flash_ex.c stm32wb0x_hal_gpio.c stm32wb0x_hal_dma.c stm32wb0x_hal_pwr.c stm32wb0x_hal_pwr_ex.c stm32wb0x_hal_cortex.c stm32wb0x_hal.c stm32wb0x_hal_pka.c stm32wb0x_hal_radio.c stm32wb0x_hal_radio_timer.c stm32wb0x_hal_rtc.c stm32wb0x_hal_rtc_ex.c stm32wb0x_hal_tim.c stm32wb0x_hal_tim_ex.c stm32wb0x_hal_uart.c stm32wb0x_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32wb0x.c
  group Middlewares/STM32_BLE
    ../Middlewares/ST/STM32_BLE/cryptolib/: libcrypto.a
    ../Middlewares/ST/STM32_BLE/stack/lib/: stm32wb0x_ble_stack.a
    ../Middlewares/ST/STM32_BLE/evt_handler/src/: ble_evt.c
    ../Middlewares/ST/STM32_BLE/queued_writes/src/: eatt_pwrq.c
    ../Middlewares/ST/STM32_BLE/stack/config/: ble_stack_user_cfg.c
  group Utilities
    ../Utilities/trace/adv_trace/: stm32_adv_trace.c
    ../Utilities/misc/: stm32_mem.c
    ../Utilities/sequencer/: stm32_seq.c
    ../Utilities/lpm/tiny_lpm/: stm32_lpm.c
software components: CMSIS:CORE 4.3.0
